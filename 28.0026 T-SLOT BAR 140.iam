# Autodesk Inventor assembly: 28.0026 T-SLOT BAR 140
## iProperties
Created: 2006-12
Part Number: 28.0026 T-SLOT BAR 140
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
